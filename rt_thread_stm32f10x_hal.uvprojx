# Keil uVision project rt_thread_stm32f10x_hal.uvprojx, settings and files
target rt_thread_stm32f10x_hal (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: rt_thread_stm32f10x_hal +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F103xE,USE_HAL_DRIVER
  c include: .\Applications;.\Hal_driver;.\Drivers;.\Debug;.\Test;.\Library;.\Library\STM32F1_HAL;.\Library\STM32F1_HAL\Inc;.\Library\STM32F1_HAL\Inc\Legacy;.\RTOS\rt_thread\include;.\RTOS\rt_thread\include\libc;.\RTOS\rt_thread\components\finsh;.\RTOS\rt_thread\components\libc\compilers\armlibc;.\RTOS\rt_thread\components\libc\compilers\armlibc\sys;.\RTOS\rt_thread\components\drivers\include;.\RTOS\rt_thread\components\drivers\include\ipc;.\RTOS\rt_thread\components\drivers\include\drivers
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group applications
    ./Applications/: main.c stm32f1xx_hal_msp.c system_stm32f1xx.c
  group drivers
    ./Drivers/: board.c drv_usart.c stm32f1xx_it.c
    ./RTOS/rt_thread/components/drivers/serial/: serial.c
    ./RTOS/rt_thread/components/drivers/src/: dataqueue.c completion.c
    ./RTOS/rt_thread/components/finsh/: cmd.c finsh_compiler.c finsh_error.c finsh_heap.c finsh_init.c finsh_ops.c finsh_node.c finsh_parser.c finsh_token.c finsh_var.c finsh_vm.c msh.c msh_cmd.c msh_file.c shell.c symbol.c
  group library
    ./Library/STM32F1_HAL/Src/: stm32f1xx_hal.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal_can.c stm32f1xx_hal_cec.c stm32f1xx_hal_cortex.c stm32f1xx_hal_crc.c stm32f1xx_hal_dac.c stm32f1xx_hal_dac_ex.c stm32f1xx_hal_dma.c stm32f1xx_hal_eth.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_hcd.c stm32f1xx_hal_i2c.c stm32f1xx_hal_i2s.c stm32f1xx_hal_irda.c stm32f1xx_hal_iwdg.c stm32f1xx_hal_mmc.c stm32f1xx_hal_nand.c stm32f1xx_hal_nor.c stm32f1xx_hal_pccard.c stm32f1xx_hal_pcd.c stm32f1xx_hal_pcd_ex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_rtc.c stm32f1xx_hal_rtc_ex.c stm32f1xx_hal_sd.c stm32f1xx_hal_smartcard.c stm32f1xx_hal_spi.c stm32f1xx_hal_spi_ex.c stm32f1xx_hal_sram.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal_usart.c stm32f1xx_hal_wwdg.c stm32f1xx_ll_adc.c stm32f1xx_ll_crc.c stm32f1xx_ll_dac.c stm32f1xx_ll_dma.c stm32f1xx_ll_exti.c stm32f1xx_ll_fsmc.c stm32f1xx_ll_gpio.c stm32f1xx_ll_i2c.c stm32f1xx_ll_pwr.c stm32f1xx_ll_rcc.c stm32f1xx_ll_rtc.c stm32f1xx_ll_sdmmc.c stm32f1xx_ll_spi.c stm32f1xx_ll_tim.c stm32f1xx_ll_usart.c stm32f1xx_ll_usb.c stm32f1xx_ll_utils.c
    ./Library/STM32F1_HAL/: startup_stm32f103xe.s
    ./RTOS/rt_thread/libcpu/arm/common/: backtrace.c div0.c showmem.c
    ./RTOS/rt_thread/libcpu/arm/cortex-m3/: context_rvds.S cpuport.c
  group rt_thread
    ./RTOS/rt_thread/src/: clock.c components.c device.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler.c signal.c slab.c thread.c timer.c
